Commit message: 0503.1

File: pioneer_description3/urdf/pioneer_description3.urdf (robot description, URDF)
Before this commit: robot pioneer_description3, 25 links, 24 joints
Joints:
- removed joint fixed
